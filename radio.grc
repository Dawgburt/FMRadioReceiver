options:
  parameters:
    generate_options: qt_gui
    id: radio
    output_language: python
    title: FM Radio Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '15000'
    low_cutoff_freq: '100'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nECE-508 Project - FM Radio Receiver - Custom Python Blocks - WBFM\n\nAuthor: Phil Nevins\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nfrom scipy.signal import firwin, lfilter\n\nclass blk(gr.sync_block):  \n    def __init__(self, quad_rate=2400000, audio_rate=48000):  \n        gr.sync_block.__init__(\n            self,\n            name=\"Clean WBFM Demodulator\",\n            in_sig=[np.complex64],\n            out_sig=[np.float32]\n        )\n        self.quad_rate = quad_rate\n        self.audio_rate = audio_rate\n        self.decim = int(quad_rate // audio_rate)\n\n        # FIR low-pass filter (cutoff just below audio range)\n        self.lpf_taps = firwin(numtaps=101, cutoff=16e3, fs=quad_rate)\n\n        # De-emphasis filter (75us for US)\n        tau = 75e-6\n        self.alpha = np.exp(-1.0 / (audio_rate * tau))\n        self.prev_y = 0.0\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n\n        # FM demod via conjugate product\n        phasor_diff = in0[1:] * np.conj(in0[:-1])\n        demod = np.angle(phasor_diff)\n        demod = np.insert(demod, 0, 0)\n\n        # FIR LPF before decimation to prevent aliasing\n        filtered_baseband = lfilter(self.lpf_taps, 1.0, demod)\n\n        # Decimate safely\n        decimated = filtered_baseband[::self.decim]\n\n        # De-emphasis filter\n        filtered = np.zeros_like(decimated)\n        for i in range(len(decimated)):\n            self.prev_y = (1 - self.alpha) * decimated[i] + self.alpha * self.prev_y\n            filtered[i] = self.prev_y\n\n        # Remove residual DC\n        filtered -= np.mean(filtered)\n\n        # Scale gain to avoid clipping\n        filtered *= 0.2\n\n        out[:len(filtered)] = filtered.astype(np.float32)\n        return len(filtered)\n\n"
    audio_rate: '48000'
    quad_rate: '2400000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: 2.4e6
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '2500000'
    fc: 107.5e6
    fftsize: '1024'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 107.5e6
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2.4e6
    sync: none
    type: fc32
  states: {}

connections:
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', epy_block_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
