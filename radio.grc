options:
  parameters:
    generate_options: qt_gui
    id: radio
    output_language: python
    title: FM Radio Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '15000'
    low_cutoff_freq: '100'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nECE-508 Project - FM Radio Receiver - Custom Python Blocks - WBFM\n\nAuthor: Phil Nevins, Arie J\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"Clean WBFM demodulator: matches built-in GNU Radio WBFM Receive\"\"\"\n\n    def __init__(self, quad_rate=2.4e6, audio_decim=10):\n        gr.sync_block.__init__(\n            self,\n            name=\"WBFM Receive Custom\",\n            in_sig=[np.complex64],\n            out_sig=[np.float32],\n        )\n        self.quad_rate = quad_rate\n        self.audio_decim = int(audio_decim)\n        self.prev_sample = 0j\n\n    def work(self, input_items, output_items):\n        x = input_items[0]\n        out = output_items[0]\n\n        n_out = len(out)\n        n_in = n_out * self.audio_decim\n\n        if len(x) < n_in:\n            return 0\n\n        x = x[:n_in]\n\n        # FM demodulation using conjugate product\n        mixed = x * np.conj(np.roll(x, 1))\n        mixed[0] = x[0] * np.conj(self.prev_sample)\n        self.prev_sample = x[-1]\n\n        demod = np.angle(mixed)\n\n        # Decimate\n        audio = demod[::self.audio_decim]\n\n        # Don't normalize or clip; let rest of flow do it\n        out[:n_out] = audio[:n_out]\n\n        return n_out\n\n"
    audio_decim: '10'
    quad_rate: '2400000.0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: 2.4e6
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '2500000'
    fc: 107.5e6
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '4'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 107.5e6
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2.4e6
    sync: none
    type: fc32
  states: {}

connections:
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_0, '0']
- [epy_block_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', epy_block_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
